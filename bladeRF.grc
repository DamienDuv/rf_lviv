options:
  parameters:
    author: damien
    generate_options: qt_gui
    id: bladeRF
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: c0_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: c1_freq
  id: variable
  parameters:
    value: 120e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"bladerf=4a48b92853454f65b01d4c4ea9719309,channel=1"'
    bb_gain0: '20'
    freq0: c0_freq
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: '"bladerf=4a48b92853454f65b01d4c4ea9719309,channel=2"'
    bb_gain0: '20'
    freq0: c1_freq
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
