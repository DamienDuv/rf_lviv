options:
  parameters:
    author: damien
    generate_options: qt_gui
    id: bladeRF2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: c0_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: c1_freq
  id: variable
  parameters:
    value: 120e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: osmosdr_source_0_1
  id: osmosdr_source
  parameters:
    args: '"bladerf=4a48b92853454f65b01d4c4ea9719309,nchan=2"'
    bb_gain0: '20'
    bb_gain1: '20'
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: c0_freq
    freq1: c1_freq
    gain0: '50'
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}

connections:
- [osmosdr_source_0_1, '0', qtgui_freq_sink_x_0_1, '0']
- [osmosdr_source_0_1, '1', qtgui_freq_sink_x_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
